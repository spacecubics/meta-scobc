FILESEXTRAPATHS:prepend := "${THISDIR}/files:"

SRC_URI:append = " \
    file://0001-assists-xparameters-Generate-selected-child-properti.patch \
"

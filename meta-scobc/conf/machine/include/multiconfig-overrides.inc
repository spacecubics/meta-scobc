## meta-scobc/conf/machine/include/scobc-devgrade.inc
```bitbake
MACHINEOVERRIDES =. "${@['', 'scobc-v1-devgrade:']['scobc-v1-devgrade' != '${MACHINE}']}"
```
